# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(25000000) ESEL ELITTLE
  output: Fire_FreeRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\User;..\Freertos\Source\include;..\Freertos\Source\portable\ARMClang\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group FreeRTOS/Ports
    ../Freertos/Source/: port.c
  group FreeRTOS/Source
    ../Freertos/Source/: list.c task.c
  group doc
    ../Doc/: readme.txt
  group user
    ../User/: main.c FreeRTOSConfig.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.2.0
